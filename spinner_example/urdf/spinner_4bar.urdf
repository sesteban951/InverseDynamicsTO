Commit message: implemented the virtual 4-bar link

File: spinner_example/urdf/spinner_4bar.urdf (robot description, URDF)
Before this commit: robot spinner, 4 links, 4 joints
Joints:
- joint theta_three: axis 0 1 0 -> 0 -1 0
